# Keil uVision project project.uvprojx, settings and files
target Target (ARM-ADS)
  output: +hex
